# Keil uVision project Project.uvprojx, settings and files
target STM32F746ZG_Nucleo (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.15.2
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: STM32F7-Nucleo_144 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F746xx,USE_HAL_DRIVER,USE_STM32F7XX_NUCLEO_144,USE_USB_FS
  c include: ../Inc;..\..\STM32F\Drivers\CMSIS\Device\ST\STM32F7xx\Include;..\..\STM32F\Drivers\STM32F7xx_HAL_Driver\Inc;..\..\STM32F\Drivers\BSP\STM32F7xx_Nucleo_144;..\..\STM32F\Drivers\BSP\Components;..\..\STM32F\Drivers\BSP\Adafruit_Shield;..\..\STM32F\Drivers\BSP\Components\st7735;..\..\STM32F\Drivers\BSP\Components\Common;..\..\STM32F\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\..\STM32F\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\..\STM32F\Middlewares\Third_Party\FatFs\src;..\..\Library\Flash\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Middlewares/STM32_USBH_Library/Class/MSC
    ../../STM32F/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
  group Application/User
    ../Src/: stm32f7xx_it.c usbh_conf.c main.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Middlewares/FatFs/Drivers
    ../Src/: usbh_diskio.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../STM32F/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_ll_usb.c stm32f7xx_hal_rcc.c stm32f7xx_hal_gpio.c stm32f7xx_ll_fmc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spi.c stm32f7xx_hal_hcd.c stm32f7xx_hal_pwr.c stm32f7xx_hal_uart.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c
  group Middlewares/FatFs/Core
    ../../STM32F/Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
  group Middlewares/STM32_USBH_Library/Core
    ../../STM32F/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Middlewares/FatFs/Option
    ../../STM32F/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Library/Flash
    ../../Library/Flash/src/: flash.c
software components: CMSIS:CORE 4.3.0
